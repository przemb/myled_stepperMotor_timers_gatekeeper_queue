# Keil uVision project myled_stepperMotor_timers_gatekeeper_queue.uvprojx, settings and files
target STM32F103RB (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: myled_freeRTOS +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\freeRTOS\include;.\freeRTOS\portable\RVDS\ARM_CM3;.\freeRTOS\portable\MemMang
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --debug
  group Source
    ./: main.c
    ./freeRTOS/: event_groups.c croutine.c list.c queue.c tasks.c timers.c
    ./freeRTOS/portable/RVDS/ARM_CM3/: port.c
    ././freeRTOS/portable/MemMang/: heap_2.c
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
